# Keil uVision project BMS_Rebuild_add_34z100.uvprojx, settings and files
target Template (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: stm32f103 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F103xB
  c include: ..\..\Drivers\CMSIS\Device\ST\STM32F1xx\Include;..\..\Drivers\STM32F1xx_HAL_Driver\Inc;..\..\Drivers\CMSIS\Include;..\..\Drivers;..\..\Users;..\..\Drivers\SYSTEM\delay;..\..\Drivers\SYSTEM\sys;..\..\Drivers\SYSTEM\uart1;..\..\Drivers\BSP\led;..\..\Drivers\BSP\io_ctrl;..\..\Drivers\BSP\soft_i2c1;..\..\Drivers\BSP\bq76940_drv;..\..\Drivers\BSP\bq76940_print;..\..\Drivers\BSP\bq76940_protect;..\..\Drivers\BSP\bq76940_alarm;..\..\Users\App;..\..\Drivers\BSP\can;..\..\Drivers\BSP\bq76200_exec_port;..\..\Drivers\BSP\bq76200_exec;..\..\Middlewares\Third_Party\FreeRTOS\Source\include;..\..\Middlewares\Third_Party\FreeRTOS\Source\portable\RVDS\ARM_CM3;..\..\Middlewares\Third_Party\FreeRTOS\Source\portable\MemMang;..\..\Drivers\BSP\bq34z100_drv;..\..\Drivers\BSP\bq76940_alert_sim;..\..\Drivers\BSP\bq76930_drv;..\..\Drivers\BSP\bq_hal;..\..\Users\Service
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Startup
    ../../Drivers/CMSIS/Device/ST/STM32F1xx/Source/Templates/arm/: startup_stm32f103xb.s
  group User
    ../../Users/: main.c stm32f1xx_it.c
    ../../Drivers/CMSIS/Device/ST/STM32F1xx/Source/Templates/: system_stm32f1xx.c
  group App
    ../../Users/App/: bq76940_app.c bq76940_app_balance.c bq76940_app_control.c bq76940_app_can.c bq76940_app_sample.c bq76940_app_protect.c bms_tasks.c bms_service.c bms_uart_host.c bq34z100_app.c bq76940_app_hw_fault.c bq76940_app_runtime_diag.c
    ../../Users/Service/: uart_service.c
    ../../Drivers/BSP/bq76200_exec/: bq76200_exec.c
  group Drivers/BSP
    ../../Drivers/BSP/led/: led.c
    ../../Drivers/BSP/io_ctrl/: io_ctrl.c
    ../../Drivers/BSP/soft_i2c1/: soft_i2c1.c
    ../../Drivers/BSP/bq76940_drv/: bq76940_drv.c
    ../../Drivers/BSP/bq76940_print/: bq76940_print.c
    ../../Drivers/BSP/bq76940_protect/: bq76940_protect.c
    ../../Drivers/BSP/bq76940_alarm/: bq76940_alarm.c
    ../../Drivers/BSP/bq76930_drv/: bq76930_drv.c
    ../../Drivers/BSP/bq_hal/: bq76930_hal.c bq76930_measure.c bq76930_balance.c
    ../../Drivers/BSP/can/: can_drv.c
    ../../Drivers/BSP/bq76200_exec_port/: bq76200_exec_port.c
    ../../Drivers/BSP/bq34z100_drv/: bq34z100_drv.c
    ../../Drivers/BSP/bq76940_alert_sim/: bq76940_alert_sim.c
  group Drivers/SYSTEM
    ../../Drivers/SYSTEM/delay/: delay.c
    ../../Drivers/SYSTEM/sys/: sys.c
    ../../Drivers/SYSTEM/uart1/: uart1.c
  group FreeRTOS
    ../../Middlewares/Third_Party/FreeRTOS/Source/: tasks.c queue.c list.c
    ../../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM3/: port.c
    ../../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
  group Drivers/STM32F1xx_HAL_Driver
    ../../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal.c stm32f1xx_hal_cortex.c stm32f1xx_hal_dma.c stm32f1xx_hal_gpio.c stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_can.c stm32f1xx_hal_uart.c stm32f1xx_hal_usart.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_pwr.c
